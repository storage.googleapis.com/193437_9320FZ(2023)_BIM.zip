Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-02-20T11:50:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 20 11:50:43 2024 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\3f6fc090-eb78-4973-b34d-4203272b41c0\c784943d-cb0b-45d5-9f2f-c9fadcedb9f5\ifc * Database version: 5507 * Database creation date: Tue Feb 20 11:50:42 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 20 11:50:43 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 20 11:50:43 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 9320FZ Oras Electra, 9320FZ(2023):9320FZ Oras Electra:438498
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 163.081 mm; NominalHeight: 190 mm; NominalWidth: 67.7216 mm
Type - Electrical - Battery: AA 1.5 V Lithium x 2; Bluetooth: 5.x (D060576); Electrical Connection: 9 V; Operating Voltage: 9 V; Protection Class: IP 55
Type - General - Author: BIMStone; BIMObjectName: 9320FZ(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 20/02/2024
Type - Green Building Properties - CO2 Emissions (A1-A3): 3.49; CO2 Emissions (A4): 0.14; CO2 Emissions (C2): 0.01; CO2 Emissions (C3): 0; CO2 Emissions (C4): 0.83; CO2 Emissions (D): -0.66; EAN Number: 6414150101908; EMC Directive: Radio Equipment Directive 2014/53/EU , Low Voltage Directive 2014/35/EU , EMC Directive 2014/30/EU , RoHS Directive 2011/65/EU; EN Standard: EN 15091, ETSI EN 301 489-1 V1.9.2 , ETSI EN 300 328 v2.2.2 , EN 61000-6-1:2007 , EN 61000-6-3:2007+A1:2011+AC:2012 , EN 60335-1:2012+A11+A13+A1+A14+A2+A15:2021, Part 19.11.4; ETIM Class Number: EC010340 Electronic tap; LVI Number: 6110446; Noise Class: I (ISO 3822); NRF Number: 4203753; RSK Number: 8430054; Sales Package dimensions (LxWxH): 568 x 182 x 78; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/9320FZ; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://www.oras.com/fileadmin/resources/189536_Oras Group EPD_Touchless composite washbasin faucet.pdf; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/188794_9320FZ_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/9320FZ; URL WEEE: http://static.oras.com/WEEE/9320FZ; VVS Number: 704268704
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/9320FZ; 3D View: https://static.oras.com/AR/9320FZ; Catalog Drawing URL: http://static.oras.com/catdrw/9320FZ; Dimension Drawing URL: http://static.oras.com/dimdrw/9320FZ; FDV Document URL: http://www.oras.com/datasheet/9320FZ/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/9320FZ; Group: Sales item; Installation and Maintenance Guide URL: http://static.oras.com/manual/9320FZ; Interactive AR View URL: https://static.oras.com/AR/9320FZ; Long Marketing: Bluetooth Touchless faucet with tilt aerator. +/- 10° adjustment option. Easy grip temperature lever for good grip and easy adjustment. SMART intelligent bluetooth sensor with 3 optical lenses for improved performance supported by app connection for personalized and easy adjustment of sensor settings. Supports Digital Network Service for remote monitoring and communication. Intelligent temperature measurement and intelligent Antiscalding protection. Metal free waterways due to high pressure composite construction and easy installation due to fast and easy 3S installation system.; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Poland;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/9320FZ; Model: 9320FZ Oras Electra; Name_en: 9320FZ Oras Electra; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 9320FZ; Product Family: Digital Touchless;Battery-operated;External transformer;Bluetooth®;Lead free; Product Image URL: http://static.oras.com/image/9320FZ; Product URL: http://static.oras.com/9320FZ; Short Marketing: Electra 93 series is giving you a whole new modern design with its rounded square body and spout giving you new fresh and updated design. The tall design compliments the new trends of modern bathroom of more square design and shallow sinks, where the extra height gives you more comfortable usage. Key Features Aerator with Tilt function +/- 10° for more flexible installation Newest Sensor technology for better detection and operation comfort Bluetooth technology for easy adjustment to personalize settings Antiscalding protection Temperature measurement Digital Network Service Battery inside body and power cable option; Technical DataSheet URL: http://www.oras.com/datasheet/9320FZ/en; Type Name: 9320FZ Oras Electra; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: 3S-installation system for safe and simple mounting;Software settings adjustable via App; Aerator: PCA® - constant flow rate regardless of pressure variations;Adjustable flow angle; Afterflow Period: 3 s (1-20 s); Automatic Flush Frequency: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Backflow Prevention EN1717: EB; Connection: Flexible inlet pipes; Connection Size: G3/8; Electronic Parts: ;Light indicated function(s);Low battery indicator; Installation Type: Deck mounted; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 2 min (1 - 1800 s); Mechanical Parts: Mixing valve for manual temperature control;Non-return valve(s);Litter filter(s); Mounting Holes: 1 hole; Operating Distance: 20-130 mm (110/130/160 mm); Spout Projection: 118 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature Adjustments: Adjustable hot water stop (included, retrofittable);; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 9320FZ(2023); Features: Washbasin faucet; Finish: Polished; Grade: n/a; Material: Composite; ModelNumber: n/a; ModelReference: 9320FZ; Name: 9320FZ Oras Electra; ReplacementCost: n/a; Shape: Sculptured; Size: 70x165x190 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 9320FZ Oras Electra; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 9320FZ; Manufacturer: Oras
Pset_ProductRequirements - Name: 9320FZ Oras Electra; Category: Plumbing Fixtures
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0559961 m2; Volume: 0.00210309 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 9320FZ(2023): 9320FZ Oras Electra; Family and Type: 9320FZ(2023): 9320FZ Oras Electra; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 9320FZ(2023): 9320FZ Oras Electra; Type Id: 9320FZ(2023): 9320FZ Oras Electra; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
